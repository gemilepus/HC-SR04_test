# Keil uVision project 01.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC89L515 Megawin
  cpu: IRAM(0-0xFF) XRAM (0x00-0x3FF) IROM(0x0-FBFF) CLOCK(48000000)
  output: 01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 01.c
